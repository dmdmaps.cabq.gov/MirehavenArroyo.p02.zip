HEC-RAS study MirehavenArroyo.prj: MirehavenArroyo

--- MirehavenArroyo.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,2066    ,40.02,49.59,54.7
XS GIS Cut Line= 3
1492366.516202381495196.807443871492331.889914691495085.67012102
1492314.487197051495029.81396152
#Sta/Elev= 27
       0 5307.265.110001 5306.78   16.17  5305.817.93001 5305.41   22.45 5304.54
   31.55 5303.09   40.72 5301.7290.24001 5300.51  102.24 5300.22  109.81 5300.47
   116.4 5300.69  133.84 5301.29  156.98 5301.89  159.28 5302.98  162.06 5304.65
  164.52 5305.46  167.75 5306.29   169.4 5306.45  170.52 5306.56   170.6 5306.55
  170.97 5306.54  171.53 5306.51  172.26 5306.48  173.26 5306.43  173.91  5306.4
  174.71 5306.36  174.91 5306.36
#Mann= 4 ,-1 , 0
       0    .045       0   22.45     .03       0  156.98    .022       0
  162.06    .045       0
Bank Sta=22.45,162.06
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2017    ,44.75,49.97,54.57
XS GIS Cut Line= 3
1492399.879983581495184.527079961492380.16879262 1495074.3495758
1492370.240466561495018.85428946
#Sta/Elev= 22
       0 5306.85   14.19 5305.78   19.73 5305.4822.35001 5304.97   26.52 5304.19
40.60001 5302.02   44.48 5301.44   66.07 5300.82  101.08 5299.84  111.93 5300.16
  118.35 5300.35   151.9 5301.36  156.33 5304.01  156.64 5304.22  157.19 5304.37
  158.64 5304.78  162.66 5306.01  163.61    5306  164.54    5306   165.3    5306
  167.01 5306.01   168.3 5306.02
#Mann= 4 ,-1 , 0
       0    .045       0   26.52     .03       0   151.9    .022       0
  156.64    .045       0
Bank Sta=26.52,156.64
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1967    ,51.32,49.88,54.29
XS GIS Cut Line= 3
1492435.108346141495178.263092061492429.310001471495066.92366541
1492426.470002441495012.39019397
#Sta/Elev= 21
       0 5306.2521.85001 5305.1131.59001 5304.7937.59001 5304.7141.57001 5304.02
42.43001  5303.958.81001 5301.5663.97001 5300.8775.42001 5300.58  100.71 5299.84
  107.29 5299.64  108.62 5299.61  109.89 5299.65  111.49 5299.71   147.4 5301.03
   150.4 5302.65  152.55 5303.86  156.26 5304.91  158.78 5305.56  164.86 5305.45
   166.1 5305.45
#Mann= 4 ,-1 , 0
       0    .045       042.43001     .03       0   147.4    .022       0
  152.55    .045       0
Bank Sta=42.43001,152.55
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1917    ,38.61,41.74,45.66
XS GIS Cut Line= 3
 1492470.97568181495178.386826381492479.189442741495066.02147364
1492482.975750531495014.22427453
#Sta/Elev= 23
       0 5304.95   29.89 5304.58   33.97 5304.44   36.47 5304.4138.83001 5304.29
   69.66  5303.570.83001 5303.2971.72001 5303.1676.14001 5302.41   88.48 5300.17
  109.66 5299.74  112.67  5299.7  114.87 5299.67  120.21 5299.81  146.64 5300.67
  150.93 5303.01  151.53 5303.41  152.18 5303.56  157.06 5304.94  159.47 5304.85
   161.3 5304.79  163.32 5304.71   164.6 5304.66
#Mann= 4 ,-1 , 0
       0    .045       0   69.66     .03       0  146.64    .022       0
  152.18    .045       0
Bank Sta=69.66,152.18
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1875    ,5,5,5
XS GIS Cut Line= 3
1492499.107365781495182.879007111492520.454992651495071.73616281
1492531.018258931495016.74028589
#Sta/Elev= 26
       0 5303.5911.45999 5303.3834.57999 5303.1152.51999    530362.73999 5302.79
67.62999 5303.0973.56999 5303.0974.96999 5303.0275.19999 5303.1975.21999 5302.79
76.68999 5301.4577.75999 5300.3478.88999  5301.279.38999 5300.9985.23999 5300.48
88.31999 5299.57  102.93 5299.51  114.35 5299.52  129.76 5299.83  146.03 5299.97
  147.99 5301.08  149.53 5301.69  150.19 5301.06  151.56 5302.91   162.9 5304.04
  169.18 5303.55
#Mann= 5 ,-1 , 0
       0    .045       075.21999    .022       088.31999     .03       0
  146.03    .022       0  151.56    .045       0
Bank Sta=75.21999,151.56
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1870    ,8,8,8.01
XS GIS Cut Line= 3
1492504.048621211495183.651872861492525.389789631495072.54265341
1492536.05750359 1495017.0029871
#Sta/Elev= 28
       0 5303.34   34.61 5302.8955.50999 5302.76   60.02 5302.67   62.17  5302.8
72.14999  5302.8    74.5 5302.68   74.89 5302.96   74.92  5302.3   77.39 5300.05
   79.18 5298.18   80.96 5299.5192.93999 5299.68   99.85 5299.62   101.6 5299.73
  105.56  5299.5  124.45 5299.64  127.53 5299.73   132.6 5299.25  136.24 5299.72
  145.99 5299.35  146.44 5299.77   146.9 5299.94  148.26 5298.63  151.09 5302.47
  162.54  5303.6  165.77 5303.65   169.7 5303.35
#Mann= 5 ,-1 , 0
       0    .045       0   74.92    .022       0   79.18     .03       0
  148.26    .022       0  151.09    .045       0
Bank Sta=74.92,151.09
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1862    ,23.51,22.56,21.78
XS GIS Cut Line= 3
1492512.023235371495184.531275181492533.285464791495073.83303836
1492544.121196281495017.41861695
#Sta/Elev= 25
       0 5302.94   34.28 5302.54   54.78 5302.42   57.14 5302.33   58.88 5302.11
   74.04 5302.33   74.08 5301.51   78.14  5297.8    81.1 5294.72   88.96 5294.61
   92.21 5294.61   99.49 5299.05  100.27 5299.06  100.68 5299.06  102.16 5298.71
  105.64 5298.13   113.9 5298.17  120.24  5298.3  124.27 5298.66  126.32 5299.01
   133.3 5294.83  144.93 5294.88  149.99 5301.75  161.47 5302.84  170.17 5302.99
#Mann= 3 , 0 , 0
       0    .045       0   74.04    .022       0  149.99    .045       0
Bank Sta=74.04,149.99
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1840    ,20.39,22.77,24.86
XS GIS Cut Line= 3
1492537.841733641495184.368503951492555.537974641495077.54744173
1492565.070049881495020.00830659
#Sta/Elev= 24
       0 5301.7934.18001 5301.4650.79001  5300.962.74001  5299.468.46001  5299.5
   68.48 5299.19   72.02 5295.9674.78001 5294.5593.35001 5294.4594.53001 5295.19
95.39001 5295.17    96.8 5294.77  113.29 5294.87  116.28 5294.94  117.44 5295.14
  120.96 5295.32  122.53 5294.33  139.82 5294.72  143.06 5299.01  143.12 5299.17
  143.76 5299.86  155.33 5300.83   157.4 5300.87   166.6 5301.82
#Mann= 3 , 0 , 0
       0    .045       068.46001    .022       0  143.12    .045       0
Bank Sta=68.46001,143.12
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1817    ,47.63,39.25,32.58
XS GIS Cut Line= 3
1492554.202780781495182.152117161492577.913579971495081.74895878
1492591.664737751495023.51980919
#Sta/Elev= 24
       0 5301.14.7100067 5301.14   17.36 5300.92   26.66  5300.8   42.11 5299.94
   44.54 5299.82   45.43 5299.74   63.22 5297.73   64.53 5296.86   69.04 5294.52
   69.09 5294.49   89.61 5294.28  101.61 5294.14  103.16 5294.15  111.11 5294.19
  130.92  5294.3  134.59 5296.55  135.22 5296.73  135.53 5296.75  137.23 5298.57
  141.38 5298.83  150.85 5300.13  160.65 5300.92     163 5301.11
#Mann= 5 ,-1 , 0
       0    .045       0   63.22    .022       0   69.09     .03       0
  130.92    .022       0  137.23    .045       0
Bank Sta=63.22,137.23
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1778    ,5.06,5.1,5.2
XS GIS Cut Line= 3
1492617.255307421495155.048892011492616.49289265 1495088.9930819
1492615.77379914 1495026.6906358
#Sta/Elev= 25
       0  5299.64.399994  5299.46.469994 5299.388.069992 5299.29   10.67 5299.19
   23.31 5298.13   31.06  5297.5   32.48 5296.54   38.37  5293.548.60999 5293.76
54.71999 5293.76   65.17 5293.81   66.06 5293.8176.43999 5293.8190.28999 5293.56
91.12999 5293.5492.12999 5293.5592.48999 5293.7793.20999 5294.32  100.44 5297.79
  110.35 5299.12  116.59 5299.87  122.13 5300.38  124.51 5300.57  128.37 5300.88
#Mann= 5 ,-1 , 0
       0    .045       0   31.06    .022       0   38.37     .03       0
92.12999    .022       0  100.44    .045       0
Bank Sta=31.06,100.44
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1772    ,5.06,5.04,5.2
XS GIS Cut Line= 3
1492622.227438831495152.749541911492621.502420071495089.93373198
1492620.780068971495027.34904838
#Sta/Elev= 30
       0 5299.545.190002 5299.29     5.5 5299.278.890007 5299.14   28.19 5297.52
   28.73 5297.48   28.93 5297.33   36.33 5293.7436.35001 5293.71   36.48 5293.71
   48.87 5293.7548.89001 5293.76   50.15 5293.79   50.44 5293.7950.49001 5293.79
   61.57 5293.59   62.82 5293.58   64.26 5293.5775.79001 5293.6676.57001 5293.83
77.56001 5293.2487.10001  5292.9   89.19 5292.96   90.02  5294.1   90.37 5294.42
    97.3 5297.74  104.62 5298.73  113.98 5299.85  122.28 5300.62  125.41 5300.86
#Mann= 5 ,-1 , 0
       0    .045       0   28.73    .022       036.35001     .03       0
   89.19    .022       0    97.3    .045       0
Bank Sta=28.73,97.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1767    ,10.74,10.12,9.92
XS GIS Cut Line= 3
1492627.200783441495150.555304421492626.497914721495089.65857931
1492625.786449091495028.01701565
#Sta/Elev= 22
       0 5299.477.210007 5299.09    27.3  5297.5   31.29  5294.5   35.27 5292.57
36.21001  5290.9   36.26 5290.8743.10001 5290.81   47.59 5293.55   52.29 5292.82
   67.25 5292.74   68.67 5292.7674.21001 5293.41   78.67 5290.76   80.37  5290.9
   86.05 5291.06   87.05 5291.94   89.56 5295.34   89.78 5295.55   94.26  5297.7
  111.46 5299.83  122.55 5300.86
#Mann= 3 , 0 , 0
       0    .045       0    27.3    .022       0   94.26    .045       0
Bank Sta=27.3,94.26
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1757    ,47.26,40.24,35.89
XS GIS Cut Line= 3
1492638.408702421495145.961179821492636.567519611495088.58313779
1492634.646494351495028.71691058
#Sta/Elev= 15
       0 5299.35   24.37 5297.52   30.52  5292.933.71001 5291.08   34.32 5290.62
40.78001  5290.743.46001 5292.09   49.25 5291.07   64.59 5291.3370.04001 5292.19
   73.06 5290.62    80.4 5291.16   88.15 5297.62  106.35 5299.79   117.3 5300.85
#Mann= 3 , 0 , 0
       0    .045       0   24.37    .022       0   88.15    .045       0
Bank Sta=24.37,88.15
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1717    ,39.1,38.4,37.92
XS GIS Cut Line= 3
1492691.78550861 1495130.25099161492675.33202044 1495079.3262474
1492659.415908161495030.06472072
#Sta/Elev= 19
       0 5298.56   11.31 5298.18   15.29 5297.92   19.63 5297.76   27.35 5297.49
   28.96 5296.32   38.42 5290.62   51.84 5290.83   52.29 5290.85   53.37 5290.85
   53.51 5290.85   66.52 5290.83   73.87 5296.05   76.28 5297.66   93.71 5299.75
   95.52 5299.93   97.41 5300.11   98.02 5300.17  105.29 5300.78
#Mann= 5 ,-1 , 0
       0    .045       0   27.35    .022       0   38.42     .03       0
   66.52    .022       0   76.28    .045       0
Bank Sta=27.35,76.28
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1679    ,10.64,11.61,12.41
XS GIS Cut Line= 3
1492733.118806151495124.449317431492711.19511202 1495065.7735741
1492694.492389691495021.07104163
#Sta/Elev= 27
       0 5297.95.2399979 5297.95.7900009 5297.93    4.57 5297.22   11.12 5296.97
   16.82 5296.62   19.62  5297.3   21.29 5297.55   24.17  5297.6   26.12 5297.59
   35.39 5296.86   46.01 5291.82   50.16 5290.49   61.46  5290.4   61.79 5290.39
   62.64 5290.39   62.98 5290.39   63.69 5290.39   72.67 5290.39    73.7 5290.37
   82.87  5296.1   84.91 5297.36   89.61 5297.95  102.57 5299.38  105.65 5299.68
  107.11 5299.82  110.36 5300.12
#Mann= 3 ,-1 , 0
       0    .045       0    4.57    .022       0   84.91    .045       0
#XS Ineff= 2 , 0
       0   26.12 5298.43               0
Permanent Ineff=
       T       F
Bank Sta=26.12,84.91
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1667    ,48.65,49.9,51.39
XS GIS Cut Line= 3
1492740.494382581495123.603875321492722.552452641495063.37649133
1492708.328922041495015.63101236
#Sta/Elev= 26
       0  5297.9.8100052  5297.91.600006 5297.871.730003 5297.874.070007 5297.17
8.790001 5296.1520.10001 5295.37   22.22 5295.25   26.05 5295.9729.39001 5296.76
32.74001 5296.69    35.4 5296.47   37.13 5295.63   39.44  5294.9   51.11 5290.38
52.97001  5290.3   55.87 5290.29   62.84 5290.17   75.26 5289.94   75.41 5289.95
84.42001  5295.6   87.14 5297.33   97.84 5298.27  107.61 5299.32     112 5299.69
  112.66 5299.74
#Mann= 3 ,-1 , 0
       0    .045       04.070007    .022       0   87.14    .045       0
#XS Ineff= 2 , 0
       029.39001 5298.32               0
Permanent Ineff=
       T       F
Bank Sta=29.39001,87.14
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1617    ,10.93,10.91,10.93
XS GIS Cut Line= 3
1492783.222812281495114.004158651492771.37585911 1495053.0718126
1492759.863546121494993.86061888
#Sta/Elev= 24
       0 5297.571.790001 5297.592.139999 5297.593.010002 5297.59   18.38 5290.85
   21.39 5289.72   32.12 5289.25   33.08 5289.21   33.77 5289.17   34.16 5289.13
   38.18 5289.32   40.53 5289.19   43.85 5288.64   46.66 5287.54   51.52 5287.57
   62.07 5287.63   77.56 5287.72   82.62 5290.85   92.56  5297.4   99.66 5297.87
  106.83 5298.45  117.87 5299.38   118.2 5299.39  122.39 5299.37
#Mann= 3 , 0 , 0
       0    .045       03.010002    .022       0   92.56    .045       0
#XS Ineff= 2 , 0
       0   38.18 5298.32               0
Permanent Ineff=
       T       F
Bank Sta=3.010002,92.56
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1606    ,208.25,203.74,207.21
XS GIS Cut Line= 3
1492793.562585871495110.020198811492782.071521021495050.91829046
1492770.388951771494990.83141895
#Sta/Elev= 26
       0  5297.51.119995 5297.52    1.25 5297.522.779999 5297.518.409996 5295.04
      13 5293.32   28.12 5288.6828.18999 5288.68   29.61 5288.48   44.96 5287.04
   45.53 5286.98   46.08 5286.88    60.4 5287.04   71.02 5287.16   75.96 5287.19
   76.44 5287.49   91.47 5297.39   102.2  5298.1   107.3 5298.51  111.56 5298.86
  112.21 5298.88   112.5 5298.89  113.59 5298.92  114.38 5298.94  115.66 5298.98
  121.42 5299.17
#Mann= 3 , 0 , 0
       0    .045       02.779999    .022       0   91.47    .045       0
#XS Ineff= 2 , 0
       0      46    5297      76       0    5297
Permanent Ineff=
       T       T
Bank Sta=2.779999,91.47
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 2 ,1523    ,,,
BEGIN DESCRIPTION:
Tierra Pintada Crossing
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
8,152,2.62,0, 2, 2, , , 0.98, 0, 0,0,,
       0   132.8
 5297.71 5297.71
    5286    5286
       0   132.8
 5297.71 5297.71
    5284    5284
BR Coef=-1 , 0 , 0 ,, 0 ,,,0.8,-1,,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Multiple Barrel Culv=1,7.5,,152,0.013,0.5,1,1,1,5286.43,5285.43, 3,Culvert #1  , 0 ,8
      50      50      61      61      72      72
Culvert Bottom n=0.013
BC Design=,, 0 ,, 0 ,,,,,,
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,1402    ,58.06,58.07,58.26
XS GIS Cut Line= 3
 1492993.55572771495071.130269731492981.977633191495011.58074238
1492968.210173131494940.77066749
#Sta/Elev= 26
       0 5289.811.589996 5289.768.870003 5289.52   14.51 5289.25   21.83 5288.69
   25.39 5288.35   34.94 5287.48   44.19 5286.56   46.32 5286.3247.03001 5286.19
   48.15 5286.15   59.13 5285.36   60.66 5285.35   62.02 5285.34   68.41 5285.24
76.18001 5286.03    83.3 5287.13   98.09 5289.79  100.14 5290.13  109.05 5291.11
  110.88 5291.33  113.41 5291.52  122.83 5292.25  124.13 5292.26  126.02 5292.32
   132.8 5292.39
#Mann= 3 , 0 , 0
       0    .045       01.589996     .03       0  113.41    .045       0
#XS Ineff= 2 , 0
       0      46    5293      76       0    5293
Permanent Ineff=
       T       T
Bank Sta=1.589996,113.41
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1344    ,75.21,74.97,75
XS GIS Cut Line= 4
1493065.434884341495111.641456581493055.732525271495088.19549852
1493038.952440891495000.369233071493012.337698611494861.06877624
#Sta/Elev= 30
       0 5289.97 9.36998 5289.5514.14998 5289.4844.82999 5289.8847.30998 5289.75
50.29999 5289.4558.70999  5288.665.31999 5288.0877.79999 5288.1384.31999 5286.47
86.04999 5285.9488.86998 5284.6696.57999 5284.43  110.61 5284.21  124.43 5284.27
  136.18 5284.54  139.29 5284.88  142.48 5285.91  157.05 5289.16  163.22 5289.48
  165.51 5289.74  167.06 5289.92  170.04 5289.83  192.01 5292.24  209.74 5295.17
     216 5296.34  224.07 5296.27  233.36 5295.92   236.8 5295.87  256.61 5295.78
#Mann= 3 , 0 , 0
       0    .045       050.29999     .03       0  165.51    .045       0
Bank Sta=50.29999,165.51
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1269    ,70.37,72.18,73.5
XS GIS Cut Line= 3
1493133.900493881495097.810507291493112.517552971494985.89308174
1493089.009455571494862.85267531
#Sta/Elev= 29
       0 5289.7527.53001 5289.9934.70001 5289.9638.99001 5289.3243.54001 5288.31
    84.5 5279.66   86.66 5279.0888.76001 5278.7690.10001 5278.4590.59001 5278.49
   98.69 5278.22  102.48 5277.96  107.09 5277.79  130.39 5277.56  133.95 5277.86
  136.04  5277.8  150.07 5283.31  153.81 5284.73  157.19 5285.89  162.42 5286.09
  164.11 5286.16  174.38 5291.25  178.37 5291.23  188.33 5291.44  192.33 5291.31
  195.58 5291.04  219.33 5291.22  233.29 5290.85  239.21 5290.86
#Mann= 3 , 0 , 0
       0    .045       043.54001     .03       0  162.42    .045       0
Bank Sta=43.54001,162.42
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1197    ,100.2,100.01,100.27
XS GIS Cut Line= 3
1493201.697845411495084.114554871493183.375902391494972.14909531
 1493165.78302251494864.63894317
#Sta/Elev= 23
       0 5288.65       4  5288.67.440002 5289.48   37.36 5288.91   41.73 5288.96
    48.2 5287.77   51.95 5286.72   68.14 5281.49   84.02  5278.2   98.19 5278.24
  121.15 5277.58  127.76 5277.81  129.93 5277.47  136.07 5277.42  138.03 5277.53
  140.37 5277.94  151.28 5282.72  159.02 5285.49  161.18 5285.42  176.18 5289.22
  178.76 5289.87  189.41 5289.99  222.39  5290.1
#Mann= 3 , 0 , 0
       0    .045       0   37.36     .03       0  176.18    .045       0
Bank Sta=37.36,176.18
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1097    ,92.41,88.38,85.63
XS GIS Cut Line= 3
1493299.752770831495064.306176471493281.556451461494953.10840346
1493265.876416711494857.28765482
#Sta/Elev= 20
       0 5287.5524.54001 5287.44   35.45 5285.65   54.89 5282.44   57.06 5282.52
63.29001 5281.2675.37001 5278.97      79  5277.6   89.26 5277.37  131.12    5277
  135.44 5277.18  137.73 5278.02  148.49 5281.56  155.38 5283.67  165.51 5285.91
  167.77  5286.4  170.22 5287.09  180.31 5287.62  191.33 5287.43  209.77 5287.73
#Mann= 3 , 0 , 0
       0    .045       0   35.45     .03       0  165.51    .045       0
Bank Sta=35.45,165.51
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1009    ,66.4,66.39,66.41
XS GIS Cut Line= 3
1493392.502902961495047.385890591493368.318514921494936.28216109
1493348.020102291494843.03070721
#Sta/Elev= 19
       0 5283.72   16.66 5283.58   26.17 5283.33    40.2 5283.4240.99001 5283.29
   45.23 5282.53   83.87 5277.25  104.52  5277.1   121.1  5277.2  136.79 5277.05
  150.84 5279.83   153.6 5280.51  154.86 5280.63  170.66 5282.91  178.33    5284
  187.86  5284.3  196.34 5284.32  202.87 5283.54  209.14 5283.71
#Mann= 3 , 0 , 0
       0    .045       040.99001     .03       0  170.66    .045       0
Bank Sta=40.99001,170.66
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,942     ,73.88,73.87,74.04
XS GIS Cut Line= 3
 1493456.09846781495027.482394651493433.495140551494923.64210096
1493411.615667131494823.12721127
#Sta/Elev= 25
       0    5282   16.41  5282.2   24.75 5282.1535.74001    5282   36.81 5281.63
   37.91 5281.24   49.89 5278.12   61.39  5275.6   71.69 5272.4178.49001 5271.46
  106.27 5270.62  117.08  5270.5  124.67  5270.5  129.38 5271.21  131.59 5271.63
  154.09 5279.11  162.49  5280.6  165.85 5280.89  170.32 5281.28  173.67 5281.74
  176.92 5281.41  195.71 5281.74  198.08 5281.65  200.55 5281.87  209.14  5281.9
#Mann= 3 , 0 , 0
       0    .045       0   36.81     .03       0  165.85    .045       0
Bank Sta=36.81,165.85
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,869     ,67.71,67.77,67.86
XS GIS Cut Line= 3
1493528.045012211495010.789120051493506.014013391494909.57811859
1493483.562211541494806.43393667
#Sta/Elev= 28
       0 5280.084.050003  5280.19.069992 5280.0510.03999 5280.08   23.58 5279.79
30.39999 5279.93   35.77 5280.02   35.97 5279.9942.00999 5278.98   46.38 5277.88
   63.17 5273.83   66.56 5272.54      70 5271.19    71.8 5271.04   78.56 5270.94
   95.11 5270.71  103.58 5270.62  111.38 5270.53  120.35 5270.74  123.07 5270.79
  124.19 5271.05  133.51 5273.05  159.57 5277.77  168.07  5279.3  175.28 5279.71
  177.69 5279.66  199.81 5279.51  209.14 5279.42
#Mann= 3 , 0 , 0
       0    .045       0   35.97     .03       0  159.57    .045       0
Bank Sta=35.97,159.57
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,801     ,76.34,76.47,76.51
XS GIS Cut Line= 3
1493595.494773461495002.442482751493572.821379151494898.28029908
1493551.011972791494798.08729937
#Sta/Elev= 28
       0  5278.54.880005 5278.55    19.2 5278.32   38.41  5278.5   40.69 5278.67
   46.88 5275.79    47.8 5275.43      49 5275.58   54.72 5275.93   62.45 5275.64
   66.03  5273.970.35001 5272.03   71.81 5272.02   84.75 5271.04   92.69 5270.57
  102.05 5270.38     123 5270.27  124.98 5270.64  145.89 5273.53  153.65 5274.98
  160.83 5275.98  164.49 5276.49  167.88 5277.11  177.57 5277.56  179.56 5277.57
  189.17 5276.98  197.07 5277.01  209.14 5276.86
#Mann= 3 , 0 , 0
       0    .045       0   46.88     .03       0  160.83    .045       0
Bank Sta=46.88,160.83
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,725     ,61.27,61.32,61.41
XS GIS Cut Line= 3
1493670.653221771494988.959473641493648.424953631494886.84221161
 1493626.17042111494784.60429026
#Sta/Elev= 30
       0 5275.621.039993 5275.654.100006 5276.047.899994 5276.08   13.81 5275.82
25.89999 5276.07   35.98 5277.35   43.06 5276.1653.42999 5275.94   58.98 5275.52
   64.11 5274.93   66.69 5273.69   75.31  5270.7   80.45 5270.73    88.4 5270.37
   94.56 5270.66  109.24 5270.51  118.87 5270.58  131.55 5270.96  149.53 5273.56
  152.17 5274.12     156 5274.51  158.11 5274.91  161.19 5275.48  163.15 5275.72
  166.33 5275.54  200.32 5275.28  203.19 5274.99   205.7 5275.25  209.14 5275.39
#Mann= 3 , 0 , 0
       0    .045       0   64.11     .03       0  158.11    .045       0
Bank Sta=64.11,158.11
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,663     ,64.7,64.88,65.19
XS GIS Cut Line= 3
1493730.52978645  1494976.0778761493708.87014885  1494876.572918
1493686.046985771494771.72269262
#Sta/Elev= 29
       0 5274.0411.46001 5274.53   20.38 5275.17   29.37 5275.25   36.86 5275.15
38.14999 5275.05   42.34 5274.31   51.41 5271.54   58.28 5271.7262.67999 5269.07
64.53999 5268.55   73.44  5265.4   79.84 5264.56   83.35 5264.34   83.86 5264.24
  103.26 5264.33  115.33 5264.55  121.68  5264.7  126.21  5265.1  139.65 5269.75
  143.43 5270.91  150.12 5270.79  153.72  5271.1  156.29 5271.32  167.89 5273.14
  173.57 5273.29  197.67 5273.09  204.29 5273.34  209.14 5273.28
#Mann= 3 , 0 , 0
       0    .045       0   58.28     .03       0  153.72    .045       0
Bank Sta=58.28,153.72
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,598     ,84.51,84.51,84.68
XS GIS Cut Line= 3
1493793.947273141494963.948318191493772.579086371494864.27473791
1493750.618892491494761.83969415
#Sta/Elev= 28
       0 5270.882.020004 5270.756.539993 5270.69   10.98 5270.79   20.45 5270.61
   21.36 5270.66   23.11 5270.61   32.27 5270.8639.06999 5270.69   42.37 5270.61
46.48999 5270.6847.95999 5270.52    57.7 5270.63   59.48 5270.1868.45999 5266.85
   75.03 5264.65    79.2 5264.0681.25999 5263.92   85.67 5263.89  115.39 5263.86
  127.79 5264.39  137.47 5268.25  148.44  5270.4  150.68  5270.7  158.98 5271.86
  162.98 5272.04  184.61 5271.73   206.7 5271.82
#Mann= 3 , 0 , 0
       0    .045       039.06999     .03       0  150.68    .045       0
Bank Sta=39.06999,150.68
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,514     ,114.41,114.41,114.41
XS GIS Cut Line= 3
1493877.275136391494949.607597861493855.547794441494848.25871013
1493834.073547851494748.09040553
#Sta/Elev= 27
       0 5270.1712.20001 5270.1431.65001 5270.3259.56001 5268.05   60.16 5267.92
65.68001 5267.81   69.94 5267.2776.59001 5264.9978.65001 5263.9881.64001 5263.33
91.90001 5263.38  103.96 5263.24  109.12 5263.33  113.72 5263.87  133.13 5265.36
  140.08 5266.51  146.72 5267.83  148.39 5267.83  153.99  5267.8  158.46 5267.58
  164.72  5267.6  173.37 5267.46  182.48 5267.66  194.93 5268.15   202.4 5267.69
  203.87 5267.47   206.1 5267.47
#Mann= 3 , 0 , 0
       0    .045       065.68001     .03       0  148.39    .045       0
Bank Sta=65.68001,148.39
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,399     ,63.13,63.13,63.13
XS GIS Cut Line= 3
1493962.53694024 1494943.09265581493968.489568261494832.97135551
1493973.307047181494743.84987153
#Sta/Elev= 25
       0 5267.84   22.88 5267.7834.78999 5267.6252.42999 5268.04   56.94 5267.89
   64.63 5265.01   67.77  5264.5   74.79 5261.43   79.27 5260.47   84.82 5259.14
    85.7 5259.06   91.99 5258.98  121.45 5258.68  128.38 5258.79  133.58 5260.46
  138.35 5261.88   147.6 5264.39   154.1 5267.24  158.09 5266.91  163.09 5266.65
  166.78  5267.1  172.73 5268.51  179.84 5268.99  194.67 5268.46  199.53 5268.54
#Mann= 3 , 0 , 0
       0    .045       0   56.94     .03       0   154.1    .045       0
Bank Sta=56.94,154.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,336     ,88.5,88.5,88.5
XS GIS Cut Line= 3
1494001.773097451494951.476947351494030.527111041494843.72758106
1494054.345115051494754.47482925
#Sta/Elev= 30
       0 5267.052.459991 5267.1523.43999 5266.58   29.06 5266.57   35.14 5266.72
40.07999 5266.61   46.81 5266.6950.70999 5265.7381.48999 5259.9885.14999  5259.2
   87.02 5259.28   90.52 5259.17   117.3 5259.43  122.88 5259.17  128.19 5259.14
  130.54 5259.25  141.92 5260.62  146.66 5262.47   152.9 5264.64  155.57 5264.46
  161.11 5264.59  173.06 5265.88  173.94 5266.07  174.92  5266.1  178.09 5265.81
  182.19 5265.64  183.37 5265.44  185.27 5265.36  197.66 5265.06   203.9 5265.02
#Mann= 3 , 0 , 0
       0    .045       0   46.81     .03       0  173.94    .045       0
Bank Sta=46.81,173.94
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,248     ,36.2,36.34,38.33
BEGIN DESCRIPTION:
Copy of station elevation data from RS24 from modified effective model
END DESCRIPTION:
XS GIS Cut Line= 3
1494099.372183531494917.161751221494115.04239326 1494869.6535107
1494130.69639175 1494822.1944187
#Sta/Elev= 7
      46 5265.41      61 5265.41      75 5258.41     100 5258.41     125 5258.41
     139 5265.41     146 5265.41
#Mann= 3 , 0 , 0
      46    .035       0      61    .028       0     139    .035       0
Bank Sta=61,139
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,212     ,194.63,195.29,203.21
BEGIN DESCRIPTION:
Copy of station elevation data from RS23 from modified effective model
END DESCRIPTION:
XS GIS Cut Line= 3
1494133.560473931494928.43831094 1494149.23162661494880.92721167
1494164.884682161494833.47097842
#Sta/Elev= 7
      46 5259.71      61 5259.71      75 5252.41     100 5252.41     125 5252.41
     139 5259.41     146 5259.71
#Mann= 3 , 0 , 0
      46    .035       0      61    .028       0     139    .035       0
Bank Sta=61,139
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18      ,48.08,49.26,52
BEGIN DESCRIPTION:
Copy of station elevation data from RS22 from modified effective model
END DESCRIPTION:
XS GIS Cut Line= 3
 1494317.70918641494989.138915741494333.373983941494941.64708365
1494349.033394621494894.17158322
#Sta/Elev= 7
      46 5258.81      61 5258.81      75 5251.81     100 5251.81     125 5251.81
     139 5258.81     146 5258.81
#Mann= 3 , 0 , 0
      46    .035       0      61    .028       0     139    .035       0
Bank Sta=61,139
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
LCMann Table=0

Chan Stop Cuts=-1
Use User Specified Reach Order=0
Composite Channel Slope=5
Composite Channel Off=-1

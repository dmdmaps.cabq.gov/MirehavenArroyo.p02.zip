HEC-RAS study MirehavenArroyo.prj: MirehavenArroyo

--- MirehavenArroyo.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,4511    ,53.22,46.95,40.65
XS GIS Cut Line= 3
1490238.239468531496129.269779631490232.612968281496063.17370948
  1490225.8736191495984.00469109
#Sta/Elev= 30
       0    5363.5799866    536328.62999 5360.4230.87999 5359.6536.88999 5353.25
   37.66 5352.5745.39999 5352.9548.09999 5352.9148.49999  5353.153.24999  5355.9
57.68999 5355.32   58.23 5355.2166.32999  5355.171.38999 5355.0373.67999 5355.04
74.52999 5355.1979.81999 5355.6886.14999 5352.47   86.23 5352.4395.75999 5352.44
96.35999 5352.45  101.26 5357.55  103.39 5359.04  106.93 5360.16  110.27 5361.16
  114.48 5361.15  129.55  5359.7  140.67 5360.04  145.52 5360.16  145.79 5360.17
#Mann= 3 , 0 , 0
       0    .045       030.87999    .022       0  103.39    .045       0
Bank Sta=30.87999,103.39
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4464    ,56.16,49.98,44.2
XS GIS Cut Line= 3
1490295.698048141496110.565452651490278.297049391496052.74953043
1490256.262183811495979.53729177
#Sta/Elev= 24
       0  5360.5   17.93 5357.15   24.77 5355.45   27.84 5353.44    30.2 5352.11
   30.86  5351.5   34.64 5352.14   54.71 5352.02    59.3 5351.39   60.37 5351.57
63.24001 5352.05   63.85 5352.19    73.5 5351.3488.74001 5351.33    89.8 5352.14
   92.42 5353.69   93.05 5354.0295.60001 5355.33   98.56 5356.11  104.33 5357.18
   111.7 5357.44  119.96 5358.02   124.1 5358.21  136.83 5358.89
#Mann= 5 ,-1 , 0
       0    .045       0   24.77    .022       0   30.86     .03       0
88.74001    .022       095.60001    .045       0
Bank Sta=24.77,95.60001
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4414    ,54.23,48.81,42.83
XS GIS Cut Line= 3
1490353.900799981496089.550053751490324.218982381496033.65795052
1490289.759970531495968.77019083
#Sta/Elev= 19
       0 5357.631.279999 5357.67   14.99  5356.4   27.57    5355    29.4 5353.76
   32.47 5351.88   50.16 5351.92   62.56 5351.92   63.28 5351.92   79.14 5351.93
   93.35 5351.89   97.41 5354.66   97.68 5354.81   98.02 5354.88  106.67 5356.68
  120.01 5356.97  123.27 5357.01  124.75 5357.04  136.75 5357.55
#Mann= 5 ,-1 , 0
       0    .045       0   27.57    .022       0   32.47     .03       0
   93.35    .022       0   98.02    .045       0
Bank Sta=27.57,98.02
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4365    ,6.03,6.01,6
XS GIS Cut Line= 3
1490400.360534261496051.223733921490366.157365221496008.84047804
1490319.879651241495951.49490893
#Sta/Elev= 26
       0 5355.626.319992 5355.2113.03999 5355.0820.53999 5354.13   26.02  5351.4
26.24999 5351.17   41.27 5351.3241.27999 5351.3243.25999 5351.3954.45999 5351.32
    57.3 5351.3168.24999 5351.25    70.2 5351.2170.20999 5351.2184.64999 5350.66
   85.84 5350.66   86.14 5350.6787.75999 5349.9591.37999 5353.6296.81999 5354.66
98.64999 5354.85  105.46 5355.63  106.21 5355.72  106.47 5355.74  118.65 5356.28
  128.15 5356.51
#Mann= 5 ,-1 , 0
       0    .045       020.53999    .022       026.24999     .03       0
87.75999    .022       091.37999    .045       0
Bank Sta=20.53999,91.37999
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4359    ,20.13,18.92,18
XS GIS Cut Line= 3
1490404.931399571496047.336958811490371.058530231496005.36299765
1490324.78144728 1495948.0182105
#Sta/Elev= 18
       0 5355.434.229996 5355.28    20.1 5353.26   21.54 5352.54   27.04 5347.33
   36.96 5347.74   42.43 5350.95   47.89 5350.02   62.95    5350      69  5350.7
   75.24 5347.46   85.42 5347.39   90.92 5352.9696.92999 5354.12   98.96 5354.62
  106.19 5355.54  118.62 5356.16  127.63 5356.41
#Mann= 3 , 0 , 0
       0    .045       0    20.1    .022       0   90.92    .045       0
Bank Sta=20.1,90.92
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4340    ,19.14,26.16,33.25
XS GIS Cut Line= 3
 1490421.18307751496035.049918781490386.487264741495994.41598373
1490339.193041081495939.02744374
#Sta/Elev= 24
       0 5354.47   19.26 5350.51   21.03 5349.55    21.6 5349.34   25.78 5347.18
   42.07 5347.43   43.53 5348.2146.67001 5347.5465.71001 5347.62    67.8 5347.96
   69.78 5348.15   71.16 5347.35   71.94 5347.04   85.36 5347.26   88.87 5350.06
   89.19  5350.490.35001 5351.31   93.37 5351.87      97 5352.84  105.25 5354.74
  107.24 5354.99  113.76 5355.39  118.91 5355.81  126.26 5356.16
#Mann= 3 , 0 , 0
       0    .045       0   19.26    .022       0   89.19    .045       0
Bank Sta=19.26,89.19
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4314    ,43.6,49.93,55.88
XS GIS Cut Line= 3
1490433.128837261496027.357033881490407.826839191495979.27510366
1490377.924682971495922.45139412
#Sta/Elev= 22
       0 5354.091.940002 5353.74   18.15 5350.32   21.49 5348.33   23.27 5347.25
   25.04 5345.89    42.9 5346.13   51.02 5346.87   54.33 5346.83   56.15  5346.8
67.24001 5346.91   77.84 5346.98   83.79 5347.03   87.11 5349.19   88.76 5350.37
   96.29 5352.05   97.41  5352.4   103.7 5353.82   103.8 5353.85  104.31 5353.91
  112.04 5354.95  118.54 5355.51
#Mann= 5 ,-1 , 0
       0    .045       0   18.15    .022       0   25.04     .03       0
   83.79    .022       0   88.76    .045       0
Bank Sta=18.15,88.76
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4264    ,43.94,49.95,56.17
XS GIS Cut Line= 3
1490468.776489711496009.924293951490454.220031811495960.89028988
1490439.49274224 1495911.2808326
#Sta/Elev= 18
       0 5352.49   13.62 5350.56   16.15  5350.1   16.84  5349.721.31001 5346.85
   44.96 5346.23   47.98 5346.17   51.15 5346.23   55.34 5346.31   67.83 5346.42
   85.06 5349.54   87.28 5349.92   87.45 5349.98   93.67    5352   99.68 5353.54
   99.99 5353.65  100.11 5353.67   102.9 5354.23
#Mann= 4 ,-1 , 0
       0    .045       0   16.15    .022       021.31001     .03       0
   87.45    .045       0
Bank Sta=16.15,87.45
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4214    ,30.5,31.03,31.62
XS GIS Cut Line= 3
1490507.572586761495998.746527781490503.191866881495951.64919541
 1490498.59723971495902.25213513
#Sta/Elev= 16
       0 5351.192.190002 5351.0314.42001 5349.73   19.55 5346.8220.06001 5346.48
   21.59 5346.47    43.1  5345.9    47.3 5345.78   51.14 5345.67   62.87 5345.48
74.18001 5347.63   84.88 5349.4686.56001 5350.05   95.16 5352.87   96.13 5353.07
   96.91  5353.1
#Mann= 4 ,-1 , 0
       0    .045       014.42001    .022       020.06001     .03       0
   84.88    .045       0
Bank Sta=14.42001,84.88
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4183    ,10.78,13.01,15.38
XS GIS Cut Line= 4
1490537.294987371495994.939088631490533.944063181495948.10022657
1490531.225318141495910.097897331490537.391359661495895.10261054
#Sta/Elev= 24
       0 5350.017.129997  5349.5   13.06 5348.8218.21999 5346.25   19.48 5345.84
   19.53 5345.81   19.91  5345.836.60999 5345.93   46.96 5345.49   47.84 5345.46
   48.26 5345.45   48.98 5345.48   61.71  5345.9   62.71  5345.964.89999 5345.85
   67.84 5345.7972.06999 5345.8878.67999 5346.5383.42999 5349.65   92.32 5351.32
   95.27  5351.7   95.96 5351.85  100.02 5352.21  101.27 5352.39
#Mann= 5 ,-1 , 0
       0    .045       0   13.06    .022       0   19.91     .03       0
78.67999    .022       083.42999    .045       0
Bank Sta=13.06,83.42999
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4170    ,29.01,28.07,27.14
XS GIS Cut Line= 3
1490546.735526671495994.546273931490546.953912131495947.92830996
1490547.226913721495889.65163652
#Sta/Elev= 28
       0  5349.73.389999 5349.45   12.96 5348.32   13.53 5348.04   13.59    5348
   18.45 5343.5920.31001 5340.57   25.65 5340.98   27.65    5341   27.93 5341.11
   34.95 5345.21   39.46 5344.5940.81001  5344.3   46.62  5344.3   51.73  5344.3
   55.47 5344.32   56.72 5344.52   61.77 5345.21   70.47 5340.45      71  5340.4
   77.72 5340.55   77.76 5340.57   83.41  5347.8    89.9 5349.28   94.12 5349.79
  101.98  5351.5  103.16  5351.6   104.9 5351.84
#Mann= 3 , 0 , 0
       0    .045       0   13.59    .022       0   83.41    .045       0
Bank Sta=13.59,83.41
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4142    ,31.15,27.98,23.82
XS GIS Cut Line= 3
1490576.19859808 1495993.7237881 1490575.01987651495947.55743666
1490573.297045111495880.08023043
#Sta/Elev= 24
       0 5348.41   12.69 5344.07   14.26 5343.59   15.08 5343.06   16.55 5341.27
   17.98  5339.9   21.38 5338.42   21.72 5338.35   22.59 5338.41   33.08 5340.44
   34.24 5340.73   35.03 5340.23   35.84 5340.09   56.89 5340.21   60.65  5340.4
   62.01 5340.02   77.21 5340.01   78.67 5341.15   83.27 5343.84    87.1 5344.74
   90.53 5345.77    92.7 5346.25  111.08  5350.8  113.68 5351.03
#Mann= 3 , 0 , 0
       0    .045       0   14.26    .022       0   83.27    .045       0
Bank Sta=14.26,83.27
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4114    ,53.23,49.61,45.41
XS GIS Cut Line= 3
1490609.490563641495990.266911281490602.650796881495944.71772542
1490591.775894861495872.29669834
#Sta/Elev= 22
       0 5347.053.800003 5346.04    13.4 5343.47   16.07 5342.96    16.6 5342.61
   18.29 5341.48   20.45 5340.24   22.46 5340.26   26.71 5340.02   46.06 5339.45
   46.23 5339.45   61.36 5339.61   61.85 5339.62    77.4    534082.24001 5342.87
   82.62 5342.96   92.88 5345.25  113.38 5349.81  114.11 5349.96  116.01 5350.24
  116.17 5350.26  119.29 5350.53
#Mann= 4 ,-1 , 0
       0    .045       0   16.07    .022       0   20.45     .03       0
   82.62    .045       0
Bank Sta=16.07,82.62
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4064    ,52.99,49.98,45.74
XS GIS Cut Line= 3
1490664.37848445 1495978.01658441490650.547947231495931.79080417
1490628.80125157 1495859.1068615
#Sta/Elev= 15
       0 5345.51.5200043 5345.52.9100037 5345.46   16.98 5342.6118.10001 5341.84
22.03001 5339.76   41.71 5339.56   46.61 5339.48   48.25 5339.51   50.62 5339.55
    77.5 5339.59    81.7 5342.43   84.88 5343.04  122.96 5348.93  124.12 5349.12
#Mann= 4 ,-1 , 0
       0    .045       0   16.98    .022       022.03001     .03       0
    81.7    .045       0
Bank Sta=16.98,81.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4014    ,53.05,49.74,45.55
XS GIS Cut Line= 3
1490716.925373831495958.000289251490698.092060491495917.19267729
1490664.925414851495845.32791398
#Sta/Elev= 13
       0 5345.05.2099991 5345.062.509995 5344.67   17.99  5342.218.64999 5341.82
   23.25  5339.339.25999 5339.1944.93999 5339.07   49.35 5338.98    83.4 5339.56
    88.2  5342.2  110.26 5345.56  124.09 5347.61
#Mann= 4 ,-1 , 0
       0    .045       0   17.99    .022       0   23.25     .03       0
    88.2    .045       0
Bank Sta=17.99,88.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3964    ,52.91,49.57,43.35
XS GIS Cut Line= 3
 1490766.02190841495930.649207171490739.53842289 1495889.6980258
1490698.14039237 1495825.6846143
#Sta/Elev= 15
       0 5344.72.5199966 5344.73   17.37 5342.01   18.11 5341.89   18.34 5341.71
   23.09 5338.98   28.07 5338.89   48.77 5338.59   52.83 5338.53    70.5  5338.7
   80.54 5338.93      98 5339.22     102 5341.84  122.82 5345.98     125 5346.47
#Mann= 4 ,-1 , 0
       0    .045       0   17.37    .022       0   23.09     .03       0
     102    .045       0
Bank Sta=17.37,102
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3915    ,53.02,50.01,40.95
XS GIS Cut Line= 3
1490810.638708091495896.55616126 1490780.84709571495862.29471472
1490727.579951531495801.03554593
#Sta/Elev= 15
       0  5344.3.5299988 5344.32   16.39 5341.68   17.26 5341.5517.81001 5341.19
   22.02 5338.81    45.4 5338.48   54.96 5338.3556.99001 5338.31   60.07 5338.32
90.46001 5338.51   108.4 5338.95   112.7 5341.55  125.27 5344.59  126.58 5344.92
#Mann= 4 ,-1 , 0
       0    .045       0   17.26    .022       0   22.02     .03       0
   112.7    .045       0
Bank Sta=17.26,112.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3865    ,53.22,49.94,43.58
XS GIS Cut Line= 3
1490849.850660511495856.460065631490815.528461021495826.75572375
1490752.035079541495771.80501726
#Sta/Elev= 27
       0 5343.89       5 5343.89   15.79 5341.29      16 5341.25    16.1 5341.24
   16.12 5341.23   16.18 5341.22   16.25 5341.21   18.43 5340.91   34.57 5338.67
   35.72 5338.53   37.28 5338.48   43.65 5338.32   45.39 5338.27   66.28 5337.74
   73.27 5337.88  103.57 5338.67  106.83 5338.69  110.82 5340.65  111.75 5341.17
  111.85 5341.18   113.5 5341.55  120.29 5342.86  125.91 5343.96  127.51 5344.15
  128.67 5344.27  129.36 5344.36
#Mann= 4 ,-1 , 0
       0    .045       0    16.1     .03       0  106.83    .022       0
  111.85    .045       0
Bank Sta=16.1,111.85
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3815    ,53.46,50,44.84
XS GIS Cut Line= 3
1490882.857952511495811.226554591490847.977881051495788.78435081
 1490770.94946011495739.22345695
#Sta/Elev= 19
       0 5343.54.3700104 5343.5512.83001 5341.0214.01001 5340.8118.23001 5340.26
35.62001 5338.0441.47001 5337.8942.97001 5337.8550.78001 5337.6262.57001 5337.28
81.93001 5337.9195.70001 5338.2498.39001 5339.61   100.8 5340.89  107.53 5341.37
  108.77  5341.6  117.03 5342.26  123.46 5342.71  133.07 5343.53
#Mann= 4 ,-1 , 0
       0    .045       012.83001     .03       095.70001    .022       0
   100.8    .045       0
Bank Sta=12.83001,100.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3765    ,36.02,36.71,38
XS GIS Cut Line= 3
1490911.201892451495762.83409445 1490869.95335621495743.91369719
1490784.235936721495704.59575343
#Sta/Elev= 19
       0  5343.3.1500092  5343.3   12.84 5340.74   14.38 5340.43   18.96 5339.79
   36.94 5337.19   45.39 5337.19   48.69 5337.19   58.72 5337.14   82.83 5337.41
   85.88 5337.49   87.45 5338.53   90.62 5340.49   96.73 5340.66   99.54  5340.8
  120.41 5341.73   123.4 5341.82  126.75 5342.05  139.69 5342.92
#Mann= 4 ,-1 , 0
       0    .045       0   14.38     .03       0   85.88    .022       0
   90.62    .045       0
Bank Sta=14.38,90.62
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3728    ,6,6,6.02
XS GIS Cut Line= 3
1490929.066101731495732.078437141490885.922369871495710.85378142
1490792.109035781495664.70210117
#Sta/Elev= 29
       0    5343.1100006    5343 .730011 5342.8815.57001 5338.56   19.27 5337.35
   19.81 5337.1721.68001 5335.67   24.73 5335.7438.18001 5336.31   38.97 5336.89
   39.98 5336.92   40.94 5336.75   48.08 5336.8458.43001 5336.9861.82001 5336.98
65.36001 5336.99   66.27 5336.9873.68001 5336.88   84.34 5336.76   84.63 5336.92
   89.89  5339.6   92.47 5339.87   98.89 5339.95  102.64 5340.49  118.58 5341.13
  124.13 5341.39  127.32 5341.58  143.78 5342.87  152.63 5343.53
#Mann= 5 ,-1 , 0
       0    .045       015.57001    .022       021.68001     .03       0
   84.34    .022       0   89.89    .045       0
Bank Sta=15.57001,89.89
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3722    ,17.8,18.75,19.86
XS GIS Cut Line= 3
1490932.129434751495726.900924981490888.531264261495705.45270716
1490792.691819621495658.30427727
#Sta/Elev= 19
       0  5342.8   15.75 5338.25   22.12 5332.8134.39999 5332.92   39.73 5336.55
45.75999 5335.56   60.73 5335.81   66.05 5336.6671.75999 5333.3984.49999 5333.75
   87.59 5336.7389.60999 5339.1489.82999 5339.3398.87999 5339.49  104.49 5340.29
  120.61 5341.04  129.19 5341.56  153.68 5343.48   155.4 5343.56
#Mann= 3 , 0 , 0
       0    .045       0   15.75    .022       089.82999    .045       0
Bank Sta=15.75,89.82999
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3703    ,35.03,38.49,43.13
XS GIS Cut Line= 3
1490941.529071031495712.461305431490898.238730771495689.43993254
1490793.244314521495633.60494501
#Sta/Elev= 30
       0 5342.128.940002 5339.57   16.22 5337.4420.23999 5334.56   22.16 5332.83
   22.61 5332.61   33.12 5332.5938.92999  5332.6   40.39 5332.64   41.93 5333.56
44.39999 5333.09   49.03 5333.1257.82999 5333.17   63.57 5333.2565.68999 5333.68
    67.1  5333.8   67.66 5333.6569.43999 5332.6485.43999 5332.8286.18999 5332.82
86.32999 5332.99   90.91 5336.88   96.13 5337.33   99.24 5338.32  108.66  5339.8
  108.91 5339.85  109.08 5339.85  136.33 5341.49  141.67 5341.91  167.95 5343.03
#Mann= 3 , 0 , 0
       0    .045       0   16.22    .022       0   90.91    .045       0
Bank Sta=16.22,90.91
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3665    ,46.69,50.27,54.37
XS GIS Cut Line= 3
1490961.508196051495687.175581751490919.031303741495657.04628498
1490809.23081803 1495579.1636707
#Sta/Elev= 29
       0 5341.68.3000031 5341.62   18.36 5336.17   32.77 5333.71   37.78  5332.7
   45.84 5332.5752.07001 5332.44      58 5332.31   71.72 5332.39   83.29 5332.57
   87.11 5332.47   91.37 5335.06   92.33 5335.73   93.63 5336.09  100.76 5338.05
  104.64 5339.22  108.19 5340.23  116.76 5340.75  118.81 5340.81  122.52 5340.26
  123.62 5340.29  127.66 5340.01  130.98 5340.15  136.36 5340.73  139.74 5341.32
  149.09 5341.66  155.53  5341.9  183.26 5342.55  186.69 5342.62
#Mann= 4 ,-1 , 0
       0    .045       0   18.36     .03       0   87.11    .022       0
   93.63    .045       0
Bank Sta=18.36,93.63
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3615    ,47.99,49.84,54.24
XS GIS Cut Line= 3
1490992.840944331495657.273158921490950.355542231495618.23221348
1490879.124012561495552.77570075
#Sta/Elev= 24
       0 5339.77.5500031 5339.79   15.33 5336.5320.76001 5335.38      23 5335.03
   38.19 5332.53    57.7 5332.06   61.57 5331.97   61.89 5331.96   61.91 5331.96
   67.97 5331.99   92.44 5331.99   92.61 5331.62   92.61 5331.61   93.91 5333.32
   94.87  5333.6   97.75 5335.33  100.48 5336.34  104.67 5338.37     113 5339.49
  117.08 5339.91  131.89 5340.64  135.57 5340.73  154.44 5341.09
#Mann= 4 ,-1 , 0
       0    .045       0   15.33     .03       0   92.61    .022       0
  100.48    .045       0
Bank Sta=15.33,100.48
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3565    ,44.33,49.84,54.11
XS GIS Cut Line= 3
1491028.044112421495633.060319311490986.902195761495584.35309476
 1490937.42640851495525.77954072
#Sta/Elev= 21
       0 5338.659.729996 5335.61   12.66 5334.9916.82999 5334.4131.59999 5332.61
55.63999 5331.9162.24999 5331.8463.75999 5331.84   78.92 5331.7782.88999 5331.79
   96.73 5330.6298.43999 5331.95  103.14 5334.66  103.92 5335.05  109.47 5336.44
  111.49 5337.01   113.4 5337.23  118.97 5338.06  121.23  5338.4   137.4 5339.17
  140.43 5339.25
#Mann= 4 ,-1 , 0
       0    .045       0   12.66     .03       0   96.73    .022       0
  103.92    .045       0
Bank Sta=12.66,103.92
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3515    ,41.68,50.18,54.81
XS GIS Cut Line= 3
1491065.71919622  1495614.6132071491026.738304811495554.48409656
1490988.596941061495495.64998089
#Sta/Elev= 20
       0 5338.18.8099976 5338.195.419998 5337.1310.82001 5334.75   11.11 5334.65
11.43001 5334.61   33.01 5331.8759.67001 5331.2267.75001 5331.03   69.73 5331.07
   71.65 5331.11  105.74  5331.8  108.26 5333.63  109.89 5334.72  119.65 5336.43
  120.18 5336.58  121.16 5336.69  122.45 5336.83  131.51 5338.02  141.77 5338.43
#Mann= 4 ,-1 , 0
       0    .045       010.82001     .03       0  105.74    .022       0
  109.89    .045       0
Bank Sta=10.82001,109.89
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3465    ,44.72,49.79,55.07
XS GIS Cut Line= 3
1491101.036635341495597.938540821491070.351642871495530.53508438
1491046.599832771495478.36123754
#Sta/Elev= 18
       0 5337.321.509995 5337.32   13.88 5334.42   14.86 5334.32   16.34 5334.08
   38.43 5331.35   51.04 5331.16   70.32 5330.63   74.06 5330.72   99.04 5331.31
  108.32 5331.51  109.07 5331.95  112.96 5334.52  115.61 5335.14  121.46 5336.51
  123.39 5336.64   127.5 5337.25  131.39  5337.6
#Mann= 4 ,-1 , 0
       0    .045       0   13.88     .03       0  108.32    .022       0
  112.96    .045       0
Bank Sta=13.88,112.96
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3415    ,20.09,21.68,23.94
XS GIS Cut Line= 3
1491135.679020281495580.454821131491116.914081931495512.90342535
1491101.006162611495455.63693537
#Sta/Elev= 20
       0 5336.461.189987 5336.463.169991    5336   11.77 5335.1523.18999 5334.04
37.91999  5330.538.21999 5330.37   38.59 5330.38   66.87 5330.33    69.7 5330.34
70.10999 5330.3472.35999 5330.3596.00999 5330.63  103.65 5330.74  108.37 5333.58
  108.95 5333.97  117.17 5335.61  120.42 5336.39  122.18 5336.53  129.54  5336.9
#Mann= 5 ,-1 , 0
       0    .045       023.18999    .022       038.21999     .03       0
  103.65    .022       0  108.95    .045       0
Bank Sta=23.18999,108.95
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3393    ,4.04,4.01,4
XS GIS Cut Line= 3
1491151.423003361495573.134925431491138.348870361495509.64596982
1491124.67271237 1495443.2335364
#Sta/Elev= 29
       0 5335.74.2400055 5335.7513.49001 5334.14   26.15 5333.81   27.58 5333.68
29.21001 5332.64    29.9 5332.13   32.34 5330.0533.86001  5330.1   45.76 5330.39
48.21001 5330.37   52.12 5330.3354.07001 5330.26   57.47 5330.2664.82001 5330.29
   78.73 5330.34   79.64  5330.3   86.11 5330.3298.67001 5330.28   99.59 5330.27
99.67001 5330.2799.68001 5330.29  100.31 5330.55  105.67    5333  113.17 5334.58
  118.71 5335.56  119.73 5335.73  121.45 5335.76  132.63 5336.61
#Mann= 5 ,-1 , 0
       0    .045       0   27.58    .022       0   32.34     .03       0
   99.59    .022       0  105.67    .045       0
Bank Sta=27.58,105.67
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3389    ,12.96,13.4,13.97
XS GIS Cut Line= 3
1491155.188172581495571.593584541491142.308586961495509.04936538
1491128.371187341495441.36832328
#Sta/Elev= 19
       0 5335.52   18.73 5333.25   27.27 5333.0231.46001 5328.4932.43001 5327.67
48.29001 5328.14   51.84 5330.1552.62001 5330.1556.69001 5329.4973.31001  5329.6
   78.52  5330.282.26001 5327.98   86.13 5327.9298.62001    5328  101.51 5331.23
  105.04 5332.83  109.47 5333.76  119.23 5335.51  132.96 5336.56
#Mann= 3 , 0 , 0
       0    .045       0   27.27    .022       0  105.04    .045       0
Bank Sta=27.27,105.04
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3376    ,23.34,25.59,28.09
XS GIS Cut Line= 3
1491166.921546171495567.277146921491155.561041981495507.05263828
1491142.121501891495435.80670718
#Sta/Elev= 19
       0 5334.7625.34999 5331.67    27.3 5330.3927.42999 5330.1730.17999 5326.95
47.77999 5327.1950.43999 5328.4350.62999 5328.45    54.8  5327.670.75999 5327.69
76.39999 5328.48   78.59 5327.2897.68999 5327.37    98.7 5328.19  103.46 5331.19
  108.06 5332.59  111.16 5333.12  119.16 5335.13  133.79 5336.29
#Mann= 3 , 0 , 0
       0    .045       025.34999    .022       0  103.46    .045       0
Bank Sta=25.34999,103.46
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3350    ,31.9,36.79,42.04
XS GIS Cut Line= 3
1491187.560967861495561.372444711491180.863472361495503.24035985
1491172.154704671495427.65108595
#Sta/Elev= 24
       0  5333.6.3600006  5333.6    4.75 5333.06   22.38 5330.84    24.8 5329.25
   25.02 5329.18   25.33 5328.96   28.22 5327.05   28.36 5327.06    41.7 5327.13
   54.52 5327.19   58.52 5327.09    61.2 5327.02   67.49 5327.23   75.57 5327.15
   92.37 5327.24   94.53 5328.63   98.53 5329.73  102.42  5330.8  105.44 5331.98
  114.85 5333.57  118.33 5334.34  122.19 5334.63  134.61 5335.61
#Mann= 5 ,-1 , 0
       0    .045       0   22.38    .022       0   28.22     .03       0
   92.37    .022       0  102.42    .045       0
Bank Sta=22.38,102.42
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3314    ,5,5.01,5.01
XS GIS Cut Line= 3
1491214.754977181495556.651352371491217.327082351495501.86246607
1491220.942740271495424.84467052
#Sta/Elev= 27
       0 5332.43    18.6 5330.57    20.3 5330.1522.39999 5327.83   26.87  5326.4
27.07999 5326.39   42.41 5326.2342.82999  5326.5    44.3 5326.59   44.66 5326.54
   54.85  5326.667.21999 5326.6768.81999 5326.6970.45999 5326.9170.64999 5326.92
   70.84 5326.8372.25999 5326.16   86.37 5326.01   87.81 5325.9692.50999 5328.75
93.50999 5330.02  100.54 5331.12  103.31 5331.73  107.68 5332.52  111.98 5332.98
   121.6 5333.65  131.95 5334.42
#Mann= 5 ,-1 , 0
       0    .045       0    20.3    .022       0   26.87     .03       0
   87.81    .022       093.50999    .045       0
Bank Sta=20.3,93.50999
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3309    ,16.8,18.38,20.3
XS GIS Cut Line= 3
1491219.782698511495556.14270349 1491222.30535631495502.40710509
1491225.927224611495425.25702071
#Sta/Elev= 28
       0 5332.24   15.53 5330.69   19.66 5329.67   24.77 5324.05   26.46 5323.51
   32.95 5323.27   37.98 5323.21   41.94 5325.72   43.15 5326.46   45.08 5326.23
   48.79 5325.68   53.36 5325.71   53.79 5325.71   64.12 5325.82   64.33 5325.85
   69.92 5326.22   75.28 5323.49   75.71  5323.379.89999 5323.25    86.8 5322.98
      88  5323.792.50999 5329.46   97.07 5330.17  102.01 5331.26  109.84 5332.67
  111.29 5332.83  114.54 5333.05  131.03 5334.28
#Mann= 3 , 0 , 0
       0    .045       0   19.66    .022       092.50999    .045       0
Bank Sta=19.66,92.50999
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3290    ,22.08,24.75,28.06
XS GIS Cut Line= 3
 1491235.32926681495555.271833611491240.58330075 1495504.4067704
1491248.397538841495428.75600037
#Sta/Elev= 30
       0 5331.736.560005 5331.07   12.32 5329.63   17.73 5327.93   23.07 5322.41
   24.45 5321.58   34.25 5321.82   38.52 5321.8139.10001    532242.35001 5323.59
   43.29 5323.44   46.51 5322.82   51.14 5322.77   55.48 5322.72   63.11 5322.63
66.85001 5323.19   68.58 5323.27   69.03 5323.08   71.58 5321.58   78.22 5321.63
   85.34 5321.67   85.59 5321.83    87.9  5324.9   90.29 5327.47   97.97 5329.21
   98.25 5329.29   98.76 5329.44  110.65  5332.4  119.63 5333.06  127.19 5333.59
#Mann= 3 , 0 , 0
       0    .045       0   17.73    .022       0   90.29    .045       0
Bank Sta=17.73,90.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3265    ,49.81,49.97,51.04
XS GIS Cut Line= 3
1491255.440411971495555.707180681491265.182397111495507.09798985
1491279.419210241495436.06113683
#Sta/Elev= 21
       0 5331.07.4599991 5331.086.799995 5328.79   14.87 5326.14    19.1 5323.44
   21.66  5321.8    31.7 5321.73   49.58 5321.51   53.88 5321.46   68.96 5321.62
   84.95 5321.86   88.72 5324.76   90.49 5325.81   91.81  5326.3      96 5327.38
   97.02 5327.69   109.6 5331.06  112.31 5331.79  112.45 5331.83   112.5 5331.83
  122.03  5332.6
#Mann= 5 ,-1 , 0
       0    .045       0   14.87    .022       0   21.66     .03       0
   84.95    .022       0   91.81    .045       0
Bank Sta=14.87,91.81
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3215    ,53.74,50.09,44.35
XS GIS Cut Line= 3
1491304.343455371495564.282591751491314.12428669 1495517.0549425
1491328.541730071495447.43898274
#Sta/Elev= 22
       0 5330.21.1500015 5330.21   11.33 5326.14   12.07 5325.92   12.35 5325.73
    15.6  5323.7   19.35  5321.4   19.56 5321.26   20.81 5321.25   23.26 5321.23
   48.23  5321.1   61.16 5321.03    77.2 5321.46   92.74 5321.88    98.4  5325.5
   99.08 5325.91   99.99 5326.24  106.04 5328.08  117.12 5330.92   118.2 5331.21
  118.57 5331.25  119.32  5331.3
#Mann= 5 ,-1 , 0
       0    .045       0   12.07    .022       0   19.56     .03       0
   92.74    .022       0   99.08    .045       0
Bank Sta=12.07,99.08
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3165    ,53.86,49.9,42.87
XS GIS Cut Line= 3
1491359.482421781495578.914655491491363.257837611495525.73856372
1491368.569408561495450.92598752
#Sta/Elev= 18
       0  5329.93.089996 5329.956.449997  5328.815.18999 5326.49   17.12 5325.95
    25.1 5321.39   26.98 5320.16   47.09 5320.39   53.31  5320.5   72.85 5320.87
   87.96 5321.22  109.26 5321.74  112.52 5323.88  115.64 5325.75  120.57  5327.3
  122.43 5327.86  123.78 5328.28  128.31 5329.74
#Mann= 5 ,-1 , 0
       0    .045       0   17.12    .022       0   26.98     .03       0
  109.26    .022       0  115.64    .045       0
Bank Sta=17.12,115.64
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3115    ,58.05,50.18,41.49
XS GIS Cut Line= 3
1491416.92316685 1495584.81401581491413.138068831495524.28656221
1491408.283680541495446.66010199
#Sta/Elev= 22
       0 5329.571.690002 5329.599.660004 5326.51   10.84 5326.13   11.42 5325.82
   12.09 5325.73    14.7 5324.93   22.79 5324.43   26.62 5324.35   27.03 5324.15
32.93999 5320.12   60.64 5320.52   70.52 5320.66   75.67 5320.68   94.22 5321.04
  122.61 5321.66  124.46 5322.91  129.48 5325.74  134.64 5327.56  135.61 5327.89
   136.8 5328.23  138.42 5328.69
#Mann= 5 ,-1 , 0
       0    .045       0   11.42    .022       032.93999     .03       0
  122.61    .022       0  129.48    .045       0
#XS Ineff= 2 , 0
       0   26.62 5326.52               0
Permanent Ineff=
       T       F
Bank Sta=11.42,129.48
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3065    ,56.31,49.6,42.35
XS GIS Cut Line= 3
1491475.054465941495581.248556471491462.380569461495517.34479914
1491446.216167591495435.84137072
#Sta/Elev= 19
       0 5329.07.8100128 5329.04    2.25 5328.559.520004  5325.8   11.41 5324.37
18.20001  5320.265.15001 5320.2471.31001 5320.25   71.88 5320.2572.04001 5320.25
  118.64 5320.51  129.98 5320.82  137.27 5325.37  137.84  5325.7  138.18 5325.82
  139.05 5326.13  144.55 5328.09  146.42 5328.64  148.24 5328.98
#Mann= 5 ,-1 , 0
       0    .045       09.520004    .022       018.20001     .03       0
  129.98    .022       0  138.18    .045       0
Bank Sta=9.520004,138.18
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3016    ,60.44,49.88,52.98
XS GIS Cut Line= 3
1491532.117000731495568.128074261491509.74390154 1495502.6220367
1491483.995571481495427.23368475
#Sta/Elev= 21
       0  5328.6.4199982 5328.61.5699921 5328.695.080002 5327.21   10.13 5325.69
   13.73 5322.8316.85001 5320.69   47.01 5320.15   67.61 5319.71   69.23 5319.74
    75.5 5319.85   92.87 5320.13  114.57  5320.4   124.7 5320.54  129.02 5323.05
  132.85  5325.7  137.15 5326.48  142.79 5327.73  145.47 5328.19  148.39 5328.59
  148.89 5328.61
#Mann= 5 ,-1 , 0
       0    .045       0   10.13    .022       016.85001     .03       0
   124.7    .022       0  132.85    .045       0
Bank Sta=10.13,132.85
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2966    ,52.44,49.92,51.82
XS GIS Cut Line= 3
1491586.405162031495545.850518061491556.943690441495486.75131179
1491524.534020711495421.73807064
#Sta/Elev= 21
       0 5328.261.269989 5328.052.699997 5327.939.509995 5327.6820.67999 5325.75
   23.05 5325.6429.81999 5322.15   33.84    532039.99999 5319.8852.41999 5319.58
66.03999 5319.3568.62999  5319.388.62999 5319.48   95.67 5319.62  101.53 5322.91
  107.14 5325.57  123.62 5327.14  128.84  5327.6  130.22 5327.64   135.9 5327.89
  138.68 5328.05
#Mann= 5 ,-1 , 0
       0    .045       0   23.05    .022       0   33.84     .03       0
   95.67    .022       0  107.14    .045       0
Bank Sta=23.05,107.14
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2916    ,32.46,32.72,32.94
XS GIS Cut Line= 3
1491629.273295061495525.211815741491601.577268071495464.39195925
1491573.261995091495402.21225241
#Sta/Elev= 21
       0 5327.732.669998 5327.412.939987  5327.44.949997 5327.26   17.45 5326.75
   18.59 5326.6928.60999 5326.17   35.02 5325.5537.35999 5324.01   44.66 5319.21
63.63999 5318.94   66.73 5318.8866.82999 5318.8969.09999 5319.1175.31999 5319.02
   90.14 5319.12   95.09 5322.15  100.12 5325.61  102.75 5326.05  115.59 5327.62
  135.15 5328.14
#Mann= 5 ,-1 , 0
       0    .045       0   35.02    .022       0   44.66     .03       0
   90.14    .022       0  100.12    .045       0
Bank Sta=35.02,100.12
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2883    ,10,10,10
XS GIS Cut Line= 3
1491658.125786811495511.32089149  1491630.9606711495449.99314221
1491598.426487181495376.54422773
#Sta/Elev= 25
       0 5327.59   14.09 5326.49   14.91 5326.52   15.52 5326.48   19.36 5326.92
23.49001 5327.29   28.93 5327.07   33.62 5325.58    41.9 5320.99   44.97 5318.97
   49.45 5318.91   56.62 5318.7666.07001 5318.64   67.08 5318.6677.60001 5318.79
89.06001 5318.7595.99001 5322.27  100.79 5325.57  108.78 5326.91  110.97 5327.18
  116.65 5327.33  119.42 5327.47  140.82 5328.89  146.03 5329.01  147.41 5329.04
#Mann= 5 ,-1 , 0
       0    .045       0   33.62    .022       0   44.97     .03       0
89.06001    .022       0  100.79    .045       0
Bank Sta=33.62,100.79
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2873    ,59.99,59.88,60.24
XS GIS Cut Line= 3
1491667.137464721495506.982252871491640.143787661495446.04154236
1491606.867031151495370.91620167
#Sta/Elev= 27
       0 5327.56 5.62001 5327.598.600006 5327.36   11.33 5327.4417.10001 5327.27
23.18001 5327.3428.00001 5327.7628.30001 5326.97   28.59 5326.9932.98001 5325.59
45.06001 5318.8945.18001 5318.8955.06001 5318.6966.65001 5318.6873.69001 5318.68
88.14001 5318.8888.14001  5320.4   88.33 5320.2491.29001 5320.4299.74001  5324.7
  100.98 5325.55  106.18 5326.38  106.41 5327.75  110.91 5327.61  117.35 5327.69
  134.67 5328.84  148.82 5329.09
#Mann= 5 ,-1 , 0
       0    .045       032.98001    .022       045.18001     .03       0
88.14001    .022       0  100.98    .045       0
#XS Ineff= 2 , 0
       045.18001  5324.9   88.14       0  5324.9
Permanent Ineff=
       T       T
Bank Sta=32.98001,100.98
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 2 ,2844    ,,,
BEGIN DESCRIPTION:
Willow Canyon Trail Crossing
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
2,55,2.62,0, 2, 2, , , 0.98, 0, 0,0,,
      25     110
    5327    5327
    5318    5318
       0     110
    5327    5327
    5318    5318
BR Coef=-1 , 0 , 0 ,, 0 ,,,0.8,-1,,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Multiple Barrel Culv=2,6,9.833,55.89,0.013,0.5,1,8,1,5318.74,5318.47, 4,Culvert #1  , 0 ,2
   50.82   48.77   61.32   59.27   71.82   69.77   82.32   80.27
Culvert Bottom n=0.013
BC Design=,, 0 ,, 0 ,,,,,,
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,2813    ,4.28,4,4.25
XS GIS Cut Line= 3
1491721.110844151495480.996971191491695.143960241495422.37434071
1491657.949659691495338.40478377
#Sta/Elev= 30
       0 5326.01.7399902 5326.0221.42999 5325.96   23.69 5326.1125.42999  5325.5
   29.89 5324.53   30.38 5324.68   37.62 5321.45   43.53 5318.6445.25999 5318.65
   64.11 5318.59   82.53 5318.53   84.48 5318.51   85.14 5318.51   86.11 5318.36
   93.13 5324.4695.67999 5323.44   97.19  5323.9   98.62 5324.75  101.47 5325.49
  105.15 5326.81  111.27 5327.25  116.41 5327.72  131.19 5326.33   132.1 5326.26
  132.73 5326.24   149.5 5327.39  152.34 5327.58  155.94 5327.74  155.95 5327.74
#Mann= 5 ,-1 , 0
       0    .045       0   30.38    .022       0   43.53     .03       0
   86.11    .022       0   93.13    .045       0
#XS Ineff= 2 , 0
       0   43.53 5324.76   86.11       0 5324.76
Permanent Ineff=
       T       T
Bank Sta=30.38,93.13
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2809    ,8.67,8.1,8.62
XS GIS Cut Line= 3
1491724.721062811495479.27403972 1491698.81720691495420.79370077
 1491661.62868111495336.83718086
#Sta/Elev= 30
       0 5325.381.339996 5325.3721.75999 5325.3124.06999 5325.0226.64999 5324.98
   29.58 5324.33   29.92 5324.44   41.72 5318.77   42.72 5318.18   42.84 5318.18
   45.82 5318.29   51.51 5318.33   55.88 5318.31   63.96 5318.25   78.98 5318.14
   86.12 5318.09   86.74 5318.05   86.79 5318.04   93.35 5320.07    99.7 5323.82
  106.01 5325.47  107.28 5325.79  108.79 5325.81  115.72 5326.45  125.07 5325.56
  127.48 5325.66  135.31 5326.11  147.93 5326.98  149.99 5327.12  155.78 5327.38
#Mann= 5 ,-1 , 0
       0    .045       0   29.92    .022       0   42.72     .03       0
   86.79    .022       0    99.7    .045       0
Bank Sta=29.92,99.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2801    ,34.17,29.76,32.38
XS GIS Cut Line= 3
1491732.129911071495475.988815771491706.262184461495417.59004201
1491669.292910381495334.12850306
#Sta/Elev= 23
       0 5324.461.919998 5324.0516.62999 5324.0125.23999 5322.9627.35999 5322.92
35.14999 5318.1241.13999 5314.2745.48999 5314.36    52.2 5317.2554.71999 5316.78
   67.31 5316.7174.92999 5316.84   77.81 5317.17   83.38 5314.2188.77999 5314.35
92.87999 5316.48  102.11 5321.94  104.43 5322.55  110.44 5324.07  114.52 5324.11
  116.35 5324.49  145.44 5326.18  155.15 5326.62
#Mann= 3 , 0 , 0
       0    .045       027.35999    .022       0  104.43    .045       0
Bank Sta=27.35999,104.43
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2771    ,44.54,55.36,67.03
XS GIS Cut Line= 3
1491758.387125861495467.008319991491733.595721511495405.82810922
1491702.90650159 1495330.0932732
#Sta/Elev= 18
       0 5321.83.9499969 5321.635.269989  5321.1   13.98 5319.27   21.78 5315.86
   24.84 5314.9526.82999 5314.15   62.37 5314.01   67.09 5314.18   86.03 5314.35
  106.01  5314.4  106.53 5314.73  107.21 5314.89   113.2 5319.25  119.06 5320.53
  121.75 5321.34  126.25  5322.1  147.73 5324.58
#Mann= 5 ,-1 , 0
       0    .045       0   13.98    .022       026.82999     .03       0
  106.01    .022       0   113.2    .045       0
Bank Sta=13.98,113.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2716    ,43.65,49.81,57.25
XS GIS Cut Line= 3
1491797.512503841495460.499520681491786.964415181495392.23190463
1491775.849078541495320.29303893
#Sta/Elev= 19
       0 5320.634.319992 5320.28 8.73999 5319.6814.95999 5318.52    15.6 5318.52
   17.23 5317.4822.25999 5314.2722.38999 5314.0163.56999 5313.5169.07999 5313.43
   74.67 5313.34  107.84 5314.19  120.33 5314.43  126.16 5317.85  126.34 5317.96
   126.4 5317.98  133.55 5320.02  141.33 5321.45  141.87 5321.55
#Mann= 5 ,-1 , 0
       0    .045       0    15.6    .022       022.38999     .03       0
  120.33    .022       0   126.4    .045       0
Bank Sta=15.6,126.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2666    ,61.26,49.66,42.94
XS GIS Cut Line= 3
1491837.094512161495461.085581821491836.533118951495387.92798821
1491835.994212721495317.70077229
#Sta/Elev= 24
       0 5319.971.330002 5319.982.100006 5319.862.240005 5319.839.130005  5319.4
    10.7 5319.27   15.22 5318.64   22.88 5317.69   23.58 5317.67   23.73 5317.69
    25.8 5316.37    30.1 5313.82   44.05 5313.58   64.25 5313.32   73.16 5313.29
   82.18 5313.26   90.81 5313.46  122.72 5313.38   126.6 5315.82   128.4 5317.19
   133.3 5318.29  139.23 5319.22  141.27 5319.45  143.39 5319.73
#Mann= 5 ,-1 , 0
       0    .045       0   23.73     .22       0    30.1     .03       0
  122.72    .022       0   128.4    .045       0
Bank Sta=23.73,128.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2617    ,5,5,5.01
XS GIS Cut Line= 3
1491896.797520431495455.046961971491885.895883441495382.78013464
1491875.739754831495315.45527387
#Sta/Elev= 25
       0 5318.44   14.57 5317.99   32.77 5317.16   46.77 5316.59   47.33  5316.5
   49.43 5315.18   53.22  5312.7   53.41 5312.63   69.08 5312.75    71.9 5312.82
   73.09 5312.94   73.34 5312.96   75.92 5312.98   79.92 5312.97   98.74 5312.78
   99.87    5313  100.67 5312.44  114.28 5311.79  120.09 5311.59  123.02 5312.74
  127.37 5316.16  129.35  5316.7  136.17 5318.03  137.17 5318.21  141.17 5318.58
#Mann= 5 ,-1 , 0
       0    .045       0   46.77    .022       0   53.41     .03       0
  120.09    .022       0  127.37    .045       0
Bank Sta=46.77,127.37
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2612    ,13.66,13.91,14.61
XS GIS Cut Line= 3
1491901.674903271495453.870269411491890.850340481495382.11436605
1491880.448567491495313.16113147
#Sta/Elev= 27
       0 5318.28   24.07 5317.5334.31001 5317.06   42.18 5316.75   48.36 5315.76
   49.76 5314.88   54.48 5310.43   66.07 5310.06    68.4 5310.03   72.22 5312.29
   72.57 5312.22   72.82 5312.17   76.72 5312.12   80.83 5312.05   94.95 5311.88
   96.15 5312.1299.82001 5312.69  103.87 5310.32  104.47 5309.96  114.83 5310.04
  120.04 5310.08  121.36  5310.8  127.11 5315.32  131.66 5316.56  134.53 5317.12
  141.42 5318.35   142.3 5318.43
#Mann= 3 , 0 , 0
       0    .045       0   48.36    .022       0  127.11    .045       0
Bank Sta=48.36,127.11
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2598    ,34.42,31.33,25.31
XS GIS Cut Line= 3
1491914.277582761495450.322969121491904.636121091495380.26186445
1491894.463958751495306.34434508
#Sta/Elev= 24
       0 5317.8529.71999    5317   36.21 5316.64   40.06 5315.4346.96999 5314.01
   48.95  5312.9   53.25 5309.7663.07999 5309.67   70.28 5309.88   71.49 5310.62
   72.59 5310.71   73.23 5310.5797.18999 5310.29   97.34 5310.4398.84999 5310.74
99.95999 5310.07  110.21 5310.07  111.39 5309.94  120.02    5310  124.67 5312.46
  127.15 5313.43  132.66 5314.98  139.64 5316.39  145.34 5317.66
#Mann= 3 , 0 , 0
       0    .045       0   40.06    .022       0  132.66    .045       0
Bank Sta=40.06,132.66
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2566    ,52.9,50.07,42.99
XS GIS Cut Line= 3
1491953.600140261495434.139233781491934.677071731495371.50207522
1491911.963791111495296.31895378
#Sta/Elev= 20
       0 5317.12   26.51 5315.58   31.96 5315.15   35.41  5314.2   39.68 5313.11
   40.71 5312.58   43.15 5312.44    55.3 5310.24   65.43  5309.8   72.73 5309.48
    79.2 5309.28   82.17 5309.29   114.8  5309.6  120.97 5309.64  123.23 5310.89
  127.29 5312.93  132.44 5314.33   135.3 5315.03  140.87 5316.31  143.97 5317.01
#Mann= 4 ,-1 , 0
       0    .045       0   39.68     .03       0  120.97    .022       0
  127.29    .045       0
Bank Sta=39.68,127.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2516    ,52.64,49.88,41.05
XS GIS Cut Line= 3
  1492002.8126861495400.174294251491981.757846141495355.01175323
1491943.147236461495272.19216138
#Sta/Elev= 19
       0 5316.64.7100067 5316.65   12.38 5315.4319.03001 5314.5723.86001 5313.08
26.17001 5312.63   31.66 5311.6343.15001  5309.849.83001 5309.6759.19001 5309.47
70.97001 5309.17  104.65 5309.32  121.24 5309.36  121.99 5309.75  126.59  5312.7
  129.61 5313.57  133.17 5314.64  140.79 5316.19  141.21 5316.28
#Mann= 4 ,-1 , 0
       0    .045       023.86001     .03       0  121.24    .022       0
  126.59    .045       0
Bank Sta=23.86001,126.59
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2466    ,52.72,50.15,43.64
XS GIS Cut Line= 3
1492045.222138241495361.002859481492024.555061051495329.39631399
1491977.152061821495256.90202572
#Sta/Elev= 18
       0 5316.141.610001 5315.943.589996 5315.539.790001 5313.06   12.61 5312.27
    19.6 5311.15   31.13 5309.2437.75999 5309.04   58.35 5308.44   58.37 5308.44
   58.39 5308.44  100.96 5308.89  105.67 5311.84  106.82 5312.47  110.55 5313.19
  113.19 5313.96  119.73 5314.85  124.38 5315.48
#Mann= 4 ,-1 , 0
       0    .045       0   12.61     .03       0  100.96    .022       0
  106.82    .045       0
Bank Sta=12.61,106.82
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2416    ,22.87,21.65,18.8
XS GIS Cut Line= 3
 1492091.09425881495329.889515791492064.608561421495299.81060315
 1492013.35967421495241.60897152
#Sta/Elev= 19
       0 5314.274.589996    53149.669998 5313.6910.93999  5313.5   15.09 5311.95
16.93999 5310.84   20.81 5310.82   33.07 5308.62   40.07 5308.39   52.63 5307.98
   55.24 5307.92    77.8 5308.07   92.71 5308.23   97.61 5311.8597.64999 5311.87
   97.74 5311.89  105.81  5313.4  114.82 5314.57  117.63 5314.94
#Mann= 4 ,-1 , 0
       0    .045       0   15.09     .03       0   92.71    .022       0
   97.74    .045       0
Bank Sta=15.09,97.74
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2395    ,7.39,7.22,6.96
XS GIS Cut Line= 3
1492113.59365369 1495318.26709051492079.979627851495284.55956898
1492026.975422681495231.40793536
#Sta/Elev= 29
       0 5313.147.419998 5312.74   17.61 5312.16   20.72 5311.71   22.05 5311.29
   23.96 5309.15    27.8 5307.78    28.8 5307.75    47.2 5307.98   47.57 5308.17
   47.61 5308.17   48.88 5308.23   49.56 5308.15   58.92 5308.03   63.75 5308.02
   73.72 5308.15   74.75 5308.21   75.27  5307.9   93.53 5307.25   96.03 5307.23
   99.78 5310.07  100.59 5310.51  100.87 5310.67  102.54 5311.48  103.34 5311.65
  108.54 5311.53  110.55 5312.19  121.56 5314.28  122.67 5314.48
#Mann= 5 ,-1 , 0
       0    .045       0   20.72    .022       0    27.8     .03       0
   96.03    .022       0  103.34    .045       0
Bank Sta=20.72,103.34
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2387    ,22.62,22.66,22.98
XS GIS Cut Line= 3
1492121.015589531495314.886950271492085.103453951495279.47575471
1492031.323311651495226.44579407
#Sta/Elev= 30
       0 5312.79   19.67 5311.73   20.55 5311.68   20.83 5311.64   25.14 5310.26
   31.29 5303.39   31.36 5303.37   33.93 5303.31    43.5 5303.35   43.87 5303.56
   50.44 5307.03   51.69 5307.69   53.65 5307.29   56.98  5306.8   66.23 5306.81
   71.89 5306.84   74.06 5307.18   77.58  5307.4   84.37 5303.34   84.54 5303.23
   97.97 5303.17    98.5 5303.17   98.61 5303.27  105.04 5310.26  109.08 5310.17
  112.57 5311.31  121.05 5312.93  124.28 5313.54  124.55 5313.59  125.96    5314
#Mann= 3 , 0 , 0
       0    .045       0   25.14    .022       0  105.04    .045       0
Bank Sta=25.14,105.04
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2365    ,51.54,48.44,41.6
XS GIS Cut Line= 3
1492143.868259051495305.782981721492101.187697381495263.51711273
1492044.966277521495207.84195117
#Sta/Elev= 23
       0  5311.89.860001 5311.27   29.45 5309.87   34.14 5307.88   35.65 5307.53
   37.54 5306.08   38.11 5305.51   40.78 5303.1459.35001 5303.0360.92001 5303.89
   61.61 5303.85   67.12 5302.94   81.14 5303.28   87.13 5303.88   87.25  5303.8
   88.63 5303.77   97.52 5303.15  109.67 5303.19  110.99 5304.34  115.01 5306.73
  119.65 5308.43   120.4 5308.61  139.19 5313.67
#Mann= 3 , 0 , 0
       0    .045       0   34.14    .022       0   120.4    .045       0
Bank Sta=34.14,120.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2316    ,47.93,50.05,56.03
XS GIS Cut Line= 3
1492199.701785391495277.01612646 1492131.23510661495225.63785509
1492066.803859421495177.28782322
#Sta/Elev= 21
       0 5309.431.820007 5309.48   34.77 5308.18   41.54 5307.9944.92001 5307.77
46.07001 5307.52   56.62 5306.18   58.65 5305.85   73.55 5303.5285.60001    5303
   96.15 5302.54   97.68  5302.5   98.84 5302.49  133.45  5302.8  137.96 5305.36
   139.6 5306.36  146.06 5308.04  146.51 5308.18  148.52 5308.56  148.92 5308.65
  166.16 5312.67
#Mann= 4 ,-1 , 0
       0    .045       0   56.62     .03       0  133.45    .022       0
   139.6    .045       0
Bank Sta=56.62,139.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2266    ,49.31,49.96,55.54
XS GIS Cut Line= 3
1492229.453706481495251.50667219 1492162.6973287 1495186.9348673
1492107.788690361495133.82308984
#Sta/Elev= 22
       0  5308.9   27.78  5307.7   37.41 5307.26   39.19 5307.0848.56001 5305.85
   57.36 5304.62   68.44 5303.29   80.79 5302.75   92.88 5302.1796.96001 5301.97
   97.05 5301.97   97.34 5301.97   125.6 5302.17  138.06 5302.35  142.26 5305.18
   143.6 5306.05  148.41 5307.19  150.61 5307.85  156.71    5309  158.47 5309.33
  160.36 5309.65  169.27 5311.11
#Mann= 4 ,-1 , 0
       0    .045       048.56001     .03       0  138.06    .022       0
   143.6    .045       0
Bank Sta=48.56001,143.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2216    ,45.04,49.92,55.41
XS GIS Cut Line= 3
1492262.152200861495231.115699971492199.343854011495152.97280521
1492158.532487151495102.19741459
#Sta/Elev= 19
       0 5308.4517.56999 5307.38    23.2 5306.9624.23999 5306.7935.64999 5305.53
38.96999 5305.0657.41999 5302.5659.67999 5302.5198.57999 5301.47  100.26  5301.5
  101.36 5301.52  133.58 5302.11  142.93 5302.18  146.44  5304.5  148.29 5305.66
  158.14 5307.68  158.36 5307.73  159.24 5307.87   165.4 5308.88
#Mann= 4 ,-1 , 0
       0    .045       035.64999     .03       0  142.93    .022       0
  148.29    .045       0
Bank Sta=35.64999,148.29
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2166    ,40.81,49.7,55
XS GIS Cut Line= 3
1492299.271311611495220.085363751492242.155728221495127.35069851
1492206.92560533 1495070.1499582
#Sta/Elev= 20
       0 5308.065.539993 5307.52   20.14 5306.36   25.92 5305.3327.59999 5305.13
    33.3 5304.27   48.12 5302.1771.03999 5301.7585.14999 5301.49  102.99 5301.15
  108.91 5301.27  137.71 5301.86   154.1 5302.23  155.67 5303.12  159.02 5305.26
  162.66 5305.99  169.26 5307.27  171.95 5307.51  171.96 5307.51  176.09 5308.16
#Mann= 4 ,-1 , 0
       0    .045       0   25.92     .03       0   154.1    .022       0
  159.02    .045       0
Bank Sta=25.92,159.02
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2117    ,38.67,50.25,54.78
XS GIS Cut Line= 3
1492333.876857711495209.596122531492284.942989171495102.05684559
1492259.674037431495046.52465733
#Sta/Elev= 20
       0 5307.69.1900024 5307.698.860001 5306.81   18.13 5305.93   23.28 5304.93
23.79001 5304.8325.79001 5304.53   42.34 5301.98    76.3 5301.36  103.74 5300.83
  118.15 5301.16  145.51 5301.79  159.61 5302.12  161.87 5303.41  164.22 5304.93
  173.36 5306.39  174.98 5306.66  175.68 5306.74  176.47 5306.85  179.16 5307.25
#Mann= 4 ,-1 , 0
       0    .045       0   23.28     .03       0  159.61    .022       0
  164.22    .045       0
Bank Sta=23.28,164.22
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
